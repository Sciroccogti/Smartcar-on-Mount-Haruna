<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SEUsmartcar_KEA.ewp</path>
    </project>
    <batchBuild />
</workspace>
