# IAR project SEUsmartcar_KEA.ewp, settings and files
configuration Flash_Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Libraries\Device\IAR-ARM; ..\Libraries\Device; ..\Libraries\Driver\src; ..\Libraries\Driver\inc; ..\Libraries\cmsis_drivers; ..\Libraries\Core\src; ..\Libraries\Core\inc; ..\Libraries\Board; ..\Libraries\Core; ..\Libraries\CMSIS\; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SEUsmartcar_KEA.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Libraries\Device\IAR-ARM\linker\KEAZ128xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\Libraries\Device\IAR-ARM\linker\KEAZ128xxx4RAM.icf
  group (top)
    ../: communicate.h control.h driver.h main.c main.h
  group Board
    ../Libraries/Board/: font.c OLED_0_96.c SEEKFREE_IIC.c SEEKFREE_MPU6050.c TFT_1_8.c
  group CMSIS
    ../Libraries/CMSIS/: cmsis_compiler.h cmsis_version.h
  group Core
    ../Libraries/Core/: core_cm0plus.h
  group Device
    ../Libraries/Device/IAR-ARM/: cstartup_M_KEA128.s
    ../Libraries/Device/: low_level_init.c SKEAZ1284.h system_SKEAZ1284.c system_SKEAZ1284.h
  group Device/debugger
    ../Libraries/Device/IAR-ARM/debugger/: KEAZ128xxx4.ddf
  group Device/flashloader
    ../Libraries/Device/IAR-ARM/flashloader/: FlashKE04Z128.out FlashKE04Z128_4.board FlashKE04Z128_4.flash FlashKE04Z128_4.mac
  group Device/linker
    ../Libraries/Device/IAR-ARM/linker/: KEAZ128xxx4.icf KEAZ128xxx4RAM.icf
  group Driver
    ../Libraries/Driver/inc/: common.h headerfile.h
    ../Libraries/Driver/src/: delay.c KEA128_ADC.c KEA128_FLASH.c KEA128_FTM.c KEA128_GPIO.c KEA128_IRQ.c KEA128_KBI.c KEA128_PIT.c KEA128_Port.c KEA128_RTC.c KEA128_spi.c KEA128_systick.c KEA128_UART.c misc.c
